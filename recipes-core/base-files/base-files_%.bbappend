FILESEXTRAPATHS:prepend:stm32mpcommon := "${THISDIR}/${PN}:"

dirs755:append = " /vendor /usr/local/"
